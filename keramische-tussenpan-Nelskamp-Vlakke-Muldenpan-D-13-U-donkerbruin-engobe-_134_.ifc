Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 5841b19a-bb89-4cba-8cc8-d211ef9b82dd.ifc
Time: 2022-04-14T14:53:31
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcBuildingElementProxy
In: Bouwlaag
Material: terracotta
Pset_Data - WUID: AgAAAL9PdgIBAAAAuYwAAAVWkAAAhlIAAMBTAADupAAAPUMCAAAA; Hyperlink: https://bcb-online.nl/s/05a29aae6f3a8447a9433154eaac99ae6; werkende lengte: 365 mm; serie: Vlakke Muldenpan D-13-U; gewicht per m²: 43,92 kg/m²; soortelijke warmte: 840 j/kg·k; KOMO productcertificaat: True; NL-SfB tabel 3: g9; vorstbestendig: True; werkende breedte: 215 mm; golfhoogte: 38 mm; KOMO attest: True; gewicht per st: 3,6 kg/st; merk: Nelskamp; STABU2: 33.41.10; lengte: 439 mm; kleur: donkerbruin engobe (134); breedte: 255 mm; eenheid: st; dikte: 10,5 mm
